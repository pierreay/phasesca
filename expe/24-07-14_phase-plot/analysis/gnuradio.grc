options:
  parameters:
    generate_options: qt_gui
    id: amp_vs_phase
    output_language: python
    title: Amplitude vs. Phase
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/novigrad/srv/annex/pro/phase_data/expe/24-07-14_phase-plot/iq.complex64
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/1000
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Amp"'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Phase"'
    type: float
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_magphase_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
